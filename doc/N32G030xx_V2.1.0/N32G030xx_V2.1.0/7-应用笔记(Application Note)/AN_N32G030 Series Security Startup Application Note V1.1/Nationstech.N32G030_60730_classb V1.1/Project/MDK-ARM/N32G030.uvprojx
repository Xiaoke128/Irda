# Keil uVision project N32G030.uvprojx, settings and files
target N32G030 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.0.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32G030_SelfTest +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: srecord_crc32.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: N32G030,USE_STDPERIPH_DRIVER
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\n32g030_std_periph_driver\inc;..\..\Drivers\CMSIS\Device\Nations\N32G0xx\Include;..\..\Middlewares\N32_SelfTest_Library\inc;..\..\Project
  asm define: ARTISAN=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\N32G030_SelfTest.sct
  group User
    ../: main.c CRC32_fast_static_lut.c n32g0xx_it.c
  group CMSIS
    ../../Drivers/CMSIS/Device/Nations/N32G0xx/Source/Templates/: system_n32g030.c
    ../../Drivers/CMSIS/Device/Nations/N32G0xx/Source/Templates/keil/: startup_n32g030.s
  group N32_SelfTest_Code
    ./: n32g0xx_STLcpurunKEIL.s n32g0xx_STLcpustartKEIL.s n32g0xx_STLRamMcMxKEIL.s
  group N32_SelfTest_Library
    ../../Middlewares/N32_SelfTest_Library/src/: n32g0xx_STLclockrun.c n32g0xx_STLclockstart.c n32g0xx_STLcrc32Run.c n32g0xx_STLmain.c n32g0xx_STLstartup.c n32g0xx_STLtranspRam.c
  group N32G030_Periph
    ../../Drivers/n32g030_std_periph_driver/Src/: misc.c n32g030_crc.c n32g030_dbg.c n32g030_dma.c n32g030_exti.c n32g030_flash.c n32g030_gpio.c n32g030_iwdg.c n32g030_pwr.c n32g030_rcc.c n32g030_rtc.c n32g030_tim.c n32g030_usart.c n32g030_wwdg.c
