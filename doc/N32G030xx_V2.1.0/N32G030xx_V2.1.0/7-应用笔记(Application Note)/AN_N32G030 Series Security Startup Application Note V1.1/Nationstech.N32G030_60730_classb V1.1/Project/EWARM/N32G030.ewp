# IAR project N32G030.ewp, settings and files
configuration N32G030 (ARM, debug)
  General.OGChipSelectEditMenu: N32G030C8 Nations N32G030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G030; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\n32g030_std_periph_driver\Inc; ..\..\Drivers\CMSIS\Device\Nations\N32G0xx\Include; ..\..\Middlewares\N32_SelfTest_Library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BrushCutter.hex
  ILINK.IlinkOutputFile: N32G030.out
  ILINK.IlinkIcfFile: N32G030x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/Nations/N32G0xx/Source/Templates/iar/: startup_n32g030_EWARM.S
  group Application/User
    ../: main.c n32g0xx_it.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/Nations/N32G0xx/Source/Templates/: system_n32g030.c
  group Drivers/N32_SelfTest_Code
    ./: n32g0xx_STLcpurunIAR.s n32g0xx_STLcpustartIAR.s n32g0xx_STLRamMcMxIAR.s
  group Drivers/N32_SelfTest_Library
    ../../Middlewares/N32_SelfTest_Library/src/: n32g0xx_STLclockrun.c n32g0xx_STLclockstart.c n32g0xx_STLcrc32Run.c n32g0xx_STLmain.c n32g0xx_STLstartup.c n32g0xx_STLtranspRam.c
  group Drivers/N32G030_Periph
    ../../Drivers/n32g030_std_periph_driver/Src/: misc.c n32g030_adc.c n32g030_crc.c n32g030_dbg.c n32g030_dma.c n32g030_exti.c n32g030_flash.c n32g030_gpio.c n32g030_hdiv.c n32g030_i2c.c n32g030_iwdg.c n32g030_lptim.c n32g030_lpuart.c n32g030_opamp.c n32g030_pwr.c n32g030_rcc.c n32g030_rtc.c n32g030_spi.c n32g030_sqrt.c n32g030_tim.c n32g030_usart.c n32g030_wwdg.c
