# Keil uVision project N32G030.uvproj, settings and files
target N32G032x (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: N32G030x
  AfterMake: cmd.exe /C copy N32G030x.axf ..\N32G030x.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM, N32G030x
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target N32G032x_32 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: N32G030x_32
  AfterMake: cmd.exe /C copy N32G030x_32.axf ..\N32G030x_32.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM, N32G030x_32
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target N32G032x_64 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: N32G030x_64
  AfterMake: cmd.exe /C copy N32G030x_64.axf ..\N32G030x_64.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM, N32G030x_64
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
