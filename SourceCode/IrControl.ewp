# IAR project IrControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G030F6 Nations N32G030F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G030; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  ICCARM.CCIncludePath2: CMSIS\core; CMSIS\device; n32g030_std_periph_driver\inc; src; hal
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IrControl.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/device/startup/: startup_n32g030_EWARM.S
    CMSIS/device/: system_n32g030.c
  group hal
    hal/: hal_gpio.c hal_timer.c hal_uart.c
  group n32g030_std_periph_driver
    n32g030_std_periph_driver/src/: misc.c n32g030_adc.c n32g030_beeper.c n32g030_comp.c n32g030_crc.c n32g030_dbg.c n32g030_dma.c n32g030_exti.c n32g030_flash.c n32g030_gpio.c n32g030_hdiv.c n32g030_i2c.c n32g030_iwdg.c n32g030_lptim.c n32g030_lpuart.c n32g030_opamp.c n32g030_pwr.c n32g030_rcc.c n32g030_rtc.c n32g030_spi.c n32g030_sqrt.c n32g030_tim.c n32g030_usart.c n32g030_wwdg.c
  group src
    src/: delay.c init.c ir_control.c main.c n32g030_it.c protocol.c
